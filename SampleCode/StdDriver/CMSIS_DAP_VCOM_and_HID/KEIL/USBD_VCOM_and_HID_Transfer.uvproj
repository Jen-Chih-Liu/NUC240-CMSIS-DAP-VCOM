# Keil uVision project USBD_VCOM_and_HID_Transfer.uvproj, settings and files
target USBD_VCOM_and_HID_Transfer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_VCOM_and_HID_Transfer
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\StdDriver\inc;..\DAP;..\..\CMSIS_DAP_VCOM_and_HID
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: descriptors.c VCOM_and_HID_Transfer.c main.c
  group Library
    ../../../../Library/StdDriver/src/: usbd.c sys.c clk.c gpio.c
  group DAP
    ../DAP/: DAP.c JTAG_DP.c SW_DP.c SWO.c
